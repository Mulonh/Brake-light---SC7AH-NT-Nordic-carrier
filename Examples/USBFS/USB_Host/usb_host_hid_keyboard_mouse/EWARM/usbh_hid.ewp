# IAR project usbh_hid.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F350xB GD GD32F350xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USB_FS; GD32F350
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F3x0\Include; ..\..\..\..\..\Firmware\GD32F3x0_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\host\class\hid\Include; ..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\host\core\Include; ..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\ustd\class\hid; ..\..\..\..\..\Firmware\GD32F3x0_usbfs_library\ustd\common; ..\..\..\..\..\Firmware; ..\..\..\..\..\Firmware\CMSIS
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_HID.srec
  ILINK.IlinkOutputFile: usbh_hid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32f3x0_it.c gd32f3x0_usb_hw.c main.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../src/: system_gd32f3x0.c
  group Doc
    ../: readme.txt
  group GD32F3x0_EVAL
    ../../../../../Utilities/: gd32f350r_eval.c
    ../src/: gd32f3x0_lcd_eval.c
    ../../usb_host_msc_udisk/src/: lcd_font.c lcd_log.c
  group GD32F3x0_StdPeriph
    ../../../../../Firmware/GD32F3x0_standard_peripheral/Source/: gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_gpio.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F3x0/Source/IAR/: startup_gd32f3x0.s
  group USB_Class
    ../../../../../Firmware/GD32F3x0_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group USB_Drivers
    ../../../../../Firmware/GD32F3x0_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32F3x0_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
